# Keil uVision project Project.uvprojx, settings and files
target PY32F002Bx5_Project (6160000::V6.16::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F002Bx5,USE_FULL_LL_DRIVER
  c include: ..\CMSIS\Device\PY32F0xx\Include;..\CMSIS\Include;..\HARDWARE;..\PY32F002B_HAL_Driver\Inc;..\USER;..\mcu_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002bxx.s system_py32f002b.c debug.h
  group Application/User
    ./: py32f002b_it.c main.c
  group Drivers/PY32F002B_HAL_Driver
    ../PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_cortex.c py32f002b_hal_flash.c py32f002b_ll_adc.c py32f002b_ll_exti.c py32f002b_ll_gpio.c py32f002b_ll_tim.c py32f002b_ll_usart.c py32f002b_ll_utils.c py32f002b_ll_pwr.c py32f002b_ll_rcc.c py32f002b_ll_lptim.c
  group Doc
    ../: README.md
  group HARDWARE
    ../HARDWARE/: adc.c flash.c gpio.c ir.c iwdg.c led.c task.c time.c usart.c
  group MCU_SDK
    ../mcu_sdk/: mcu_api.c protocol.c system.c readme.txt bluetooth.h
